options:
  parameters:
    author: Martyn van Dijke
    generate_options: no_gui
    id: lora_sim_multi
    output_language: python
    run_options: run
    title: Simulated multi stream
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '4'
  states: {}
- name: frame_period
  id: variable
  parameters:
    value: '200'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: mult_const
  id: variable
  parameters:
    value: '1'
  states: {}
- name: multi_control
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: n_frame
  id: variable
  parameters:
    value: '8'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: bw
  states: {}
- name: sf
  id: variable
  parameters:
    value: '11'
  states: {}
- name: sf1
  id: variable
  parameters:
    value: '11'
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: after_thort
    type: complex
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    name: before_throt
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    ignoretag: 'False'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '4'
    minoutbuf: 2**sf*4*2
    taps: (-0.128616616593872,-0.212206590789194,-0.180063263231421,3.89817183251938e-17,0.300105438719035,0.636619772367581,0.900316316157106,1,0.900316316157106,0.636619772367581,0.300105438719035,3.89817183251938e-17,-0.180063263231421,-0.212206590789194,-0.128616616593872)
    type: ccf
  states: {}
- name: lora_sdr_hier_rx_0
  id: lora_sdr_hier_rx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: lora_sdr_hier_tx_0
  id: lora_sdr_hier_tx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    mean: '200'
    multi_control: multi_control
    n_frames: n_frame
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf
    src_data: sTomvXMuARDzMfJltZ4xSJ0dLGMDueK8PH00maiTXhiew9HzJmZzKNoP4zHkWGRC
  states: {}
- name: lora_sdr_hier_tx_0_2
  id: lora_sdr_hier_tx
  parameters:
    bw: bw
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    mean: '200'
    multi_control: 'False'
    n_frames: n_frame
    pay_len: pay_len
    samp_rate: samp_rate
    sf: sf1
    src_data: sTomvXMuARDzMfJltZ4xSJ0dLGMDueK8PH00maiTXhiew9HzJmZzKNoP4zHkWGRC
  states: {}
- name: lora_sdr_multi_control_1
  id: lora_sdr_multi_control
  parameters:
    num_ctrl: '2'
  states: {}

connections:
- [blocks_add_xx_2, '0', blocks_tag_debug_0_0, '0']
- [blocks_add_xx_2, '0', blocks_throttle_1, '0']
- [blocks_throttle_1, '0', blocks_tag_debug_0, '0']
- [blocks_throttle_1, '0', interp_fir_filter_xxx_0, '0']
- [interp_fir_filter_xxx_0, '0', lora_sdr_hier_rx_0, '0']
- [lora_sdr_hier_rx_0, ctrl_out, lora_sdr_multi_control_1, ctrl_in]
- [lora_sdr_hier_tx_0, '0', blocks_add_xx_2, '0']
- [lora_sdr_hier_tx_0_2, '0', blocks_add_xx_2, '1']
- [lora_sdr_multi_control_1, ctrl_out0, lora_sdr_hier_tx_0_2, ctrl_in]
- [lora_sdr_multi_control_1, ctrl_out1, lora_sdr_hier_tx_0, ctrl_in]

metadata:
  file_format: 1
